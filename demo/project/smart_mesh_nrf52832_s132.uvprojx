# Keil uVision project smart_mesh_nrf52832_s132.uvprojx, settings and files
target nrf52832_xxaa (5060020::V5.06 (build 20)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD NRF_SD_BLE_API_VERSION=3 S132 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 CONFIG_GPIO_AS_PINRESET NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 SOFTDEVICE_PRESENT NRF52832 NRF52 SWI_DISABLE0 MEM_MANAGER_ENABLED CFG_SEC_CON SM_PORT_PLATFORM=2 SM_CFG_EASY_CONF SM_CFG_EASY_CONFSM_CONF_PB_GATT_ONLY SM_CONF_PROXY_GATT_CLIENT SM_CONF_PROXY_GATT_SERVER
  c include: ..\..\nrf5_sdk\components;..\..\nrf5_sdk\components\ble\ble_advertising;..\..\nrf5_sdk\components\ble\ble_db_discovery;..\..\nrf5_sdk\components\ble\ble_dtm;..\..\nrf5_sdk\components\ble\ble_racp;..\..\nrf5_sdk\components\ble\ble_services\ble_ancs_c;..\..\nrf5_sdk\components\ble\ble_services\ble_ans_c;..\..\nrf5_sdk\components\ble\ble_services\ble_bas;..\..\nrf5_sdk\components\ble\ble_services\ble_bas_c;..\..\nrf5_sdk\components\ble\ble_services\ble_cscs;..\..\nrf5_sdk\components\ble\ble_services\ble_cts_c;..\..\nrf5_sdk\components\ble\ble_services\ble_dfu;..\..\nrf5_sdk\components\ble\ble_services\ble_dis;..\..\nrf5_sdk\components\ble\ble_services\ble_gls;..\..\nrf5_sdk\components\ble\ble_services\ble_hids;..\..\nrf5_sdk\components\ble\ble_services\ble_hrs;..\..\nrf5_sdk\components\ble\ble_services\ble_hrs_c;..\..\nrf5_sdk\components\ble\ble_services\ble_hts;..\..\nrf5_sdk\components\ble\ble_services\ble_ias;..\..\nrf5_sdk\components\ble\ble_services\ble_ias_c;..\..\nrf5_sdk\components\ble\ble_services\ble_lbs;..\..\nrf5_sdk\components\ble\ble_services\ble_lbs_c;..\..\nrf5_sdk\components\ble\ble_services\ble_lls;..\..\nrf5_sdk\components\ble\ble_services\ble_nus;..\..\nrf5_sdk\components\ble\ble_services\ble_nus_c;..\..\nrf5_sdk\components\ble\ble_services\ble_rscs;..\..\nrf5_sdk\components\ble\ble_services\ble_rscs_c;..\..\nrf5_sdk\components\ble\ble_services\ble_tps;..\..\nrf5_sdk\components\ble\common;..\..\nrf5_sdk\components\ble\nrf_ble_gatt;..\..\nrf5_sdk\components\ble\nrf_ble_qwr;..\..\nrf5_sdk\components\ble\peer_manager;..\..\nrf5_sdk\components\boards;..\..\nrf5_sdk\components\drivers_nrf\adc;..\..\nrf5_sdk\components\drivers_nrf\clock;..\..\nrf5_sdk\components\drivers_nrf\common;..\..\nrf5_sdk\components\drivers_nrf\comp;..\..\nrf5_sdk\components\drivers_nrf\delay;..\..\nrf5_sdk\components\drivers_nrf\gpiote;..\..\nrf5_sdk\components\drivers_nrf\hal;..\..\nrf5_sdk\components\drivers_nrf\i2s;..\..\nrf5_sdk\components\drivers_nrf\lpcomp;..\..\nrf5_sdk\components\drivers_nrf\pdm;..\..\nrf5_sdk\components\drivers_nrf\power;..\..\nrf5_sdk\components\drivers_nrf\ppi;..\..\nrf5_sdk\components\drivers_nrf\pwm;..\..\nrf5_sdk\components\drivers_nrf\qdec;..\..\nrf5_sdk\components\drivers_nrf\rng;..\..\nrf5_sdk\components\drivers_nrf\rtc;..\..\nrf5_sdk\components\drivers_nrf\saadc;..\..\nrf5_sdk\components\drivers_nrf\spi_master;..\..\nrf5_sdk\components\drivers_nrf\spi_slave;..\..\nrf5_sdk\components\drivers_nrf\swi;..\..\nrf5_sdk\components\drivers_nrf\timer;..\..\nrf5_sdk\components\drivers_nrf\twi_master;..\..\nrf5_sdk\components\drivers_nrf\twis_slave;..\..\nrf5_sdk\components\drivers_nrf\uart;..\..\nrf5_sdk\components\drivers_nrf\usbd;..\..\nrf5_sdk\components\drivers_nrf\wdt;..\..\nrf5_sdk\components\libraries\bsp;..\..\nrf5_sdk\components\libraries\button;..\..\nrf5_sdk\components\libraries\crc16;..\..\nrf5_sdk\components\libraries\crc32;..\..\nrf5_sdk\components\libraries\csense;..\..\nrf5_sdk\components\libraries\csense_drv;..\..\nrf5_sdk\components\libraries\experimental_section_vars;..\..\nrf5_sdk\components\libraries\fds;..\..\nrf5_sdk\components\libraries\fstorage;..\..\nrf5_sdk\components\libraries\gpiote;..\..\nrf5_sdk\components\libraries\hardfault;..\..\nrf5_sdk\components\libraries\hci;..\..\nrf5_sdk\components\libraries\led_softblink;..\..\nrf5_sdk\components\libraries\log;..\..\nrf5_sdk\components\libraries\log\src;..\..\nrf5_sdk\components\libraries\low_power_pwm;..\..\nrf5_sdk\components\libraries\mem_manager;..\..\nrf5_sdk\components\libraries\pwm;..\..\nrf5_sdk\components\libraries\queue;..\..\nrf5_sdk\components\libraries\scheduler;..\..\nrf5_sdk\components\libraries\slip;..\..\nrf5_sdk\components\libraries\timer;..\..\nrf5_sdk\components\libraries\twi;..\..\nrf5_sdk\components\libraries\uart;..\..\nrf5_sdk\components\libraries\usbd;..\..\nrf5_sdk\components\libraries\usbd\class\audio;..\..\nrf5_sdk\components\libraries\usbd\class\cdc;..\..\nrf5_sdk\components\libraries\usbd\class\cdc\acm;..\..\nrf5_sdk\components\libraries\usbd\class\hid;..\..\nrf5_sdk\components\libraries\usbd\class\hid\generic;..\..\nrf5_sdk\components\libraries\usbd\class\hid\kbd;..\..\nrf5_sdk\components\libraries\usbd\class\hid\mouse;..\..\nrf5_sdk\components\libraries\usbd\class\msc;..\..\nrf5_sdk\components\libraries\usbd\config;..\..\nrf5_sdk\components\libraries\util;..\..\nrf5_sdk\components\softdevice\common\softdevice_handler;..\..\nrf5_sdk\components\softdevice\s132\headers;..\..\nrf5_sdk\components\softdevice\s132\headers\nrf52;..\..\nrf5_sdk\components\toolchain;..\..\nrf5_sdk\external\segger_rtt;..\..\api;..\..\demo
  asm define: BLE_STACK_SUPPORT_REQD NRF_SD_BLE_API_VERSION=3 S132 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 CONFIG_GPIO_AS_PINRESET NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 SOFTDEVICE_PRESENT NRF52832 NRF52 SWI_DISABLE0
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DNRF_SD_BLE_API_VERSION=3,-DS132,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DCONFIG_GPIO_AS_PINRESET,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DSOFTDEVICE_PRESENT,-DNRF52832,-DNRF52,-DSWI_DISABLE0
  asm include: ..\..\..\config;..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\..\components\ble\ble_db_discovery;..\..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\components\drivers_nrf\adc;..\..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\components\drivers_nrf\comp;..\..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\components\drivers_nrf\i2s;..\..\..\..\..\..\..\components\drivers_nrf\lpcomp;..\..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\..\..\components\drivers_nrf\power;..\..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\..\components\drivers_nrf\pwm;..\..\..\..\..\..\..\components\drivers_nrf\qdec;..\..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\..\components\drivers_nrf\swi;..\..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\..\components\drivers_nrf\usbd;..\..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\components\libraries\twi;..\..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\..\components\libraries\usbd\config;..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20005000 size 0xb000
  group Application
    ../: nrf_gap.c nrf_main.c nrf_light.c nrf_switch.c nrf_admin.c nrf_provc.c nrf_provs.c nrf_proxys.c nrf_proxyc.c nrf_sys.c nrf_ipc.c nrf_db_virtual.c mesh_config.c
  group Library
    ../../lib/: smart_mesh_for_nrf52832.lib
  group Board Definition
    ../../nrf5_sdk/components/boards/: boards.c
  group Board Support
    ../../nrf5_sdk/components/libraries/bsp/: bsp.c
  group nRF_BLE
    ../../nrf5_sdk/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../nrf5_sdk/components/ble/ble_db_discovery/: ble_db_discovery.c
    ../../nrf5_sdk/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_Drivers
    ../../nrf5_sdk/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../nrf5_sdk/components/drivers_nrf/common/: nrf_drv_common.c
    ../../nrf5_sdk/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../nrf5_sdk/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
  group nRF_Libraries
    ../../nrf5_sdk/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
    ../../nrf5_sdk/components/libraries/timer/: app_timer.c
    ../../nrf5_sdk/components/libraries/hardfault/: hardfault_implementation.c
    ../../nrf5_sdk/components/libraries/button/: app_button.c
    ../../nrf5_sdk/components/libraries/mem_manager/: mem_manager.c
  group nRF_Log
    ../../nrf5_sdk/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../nrf5_sdk/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../nrf5_sdk/components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_s132_nrf52_3.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: s132_nrf52_3.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config\ble_app_att_mtu_throughput_pca10040_s132;..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x200046c8 size 0xb938
software components: CMSIS:CORE 5.0.2, CMSIS:CORE 4.3.0, Device:Startup 8.11.1
